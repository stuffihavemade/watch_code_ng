# IAR project ez430_chronos_datalogger.ewp, settings and files
configuration 915MHz - Limited IAR Kickstart (USA) (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ISM_US; MRFI_CC430; __CC430F6137__
  ICC430.IExtraOptions: -f"simpliciti\Applications\configuration\End Device\smpl_config.dat"; -f"simpliciti\Applications\configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: ; include\; driver\; logic\; bluerobin\; simpliciti\; simpliciti\Components\bsp; simpliciti\Components\bsp\drivers; simpliciti\Components\bsp\boards\CC430EM; simpliciti\Components\mrfi; simpliciti\Components\nwk; simpliciti\Components\nwk_applications
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: lnkCC430F6137.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: --ks_version
configuration 868MHz - Limited IAR Kickstart (Europe) (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ISM_EU; MRFI_CC430; __CC430F6137__
configuration 433MHz - Limited IAR Kickstart (Other regions) (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ISM_LF; MRFI_CC430
configuration 915MHz - Unrestricted IAR Workbench (USA) (MSP430, debug)
  as the first configuration, except:
configuration 868MHz - Unrestricted IAR Workbench (Europe) (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ISM_EU; MRFI_CC430; __CC430F6137__
configuration 433MHz - Unrestricted IAR Workbench (Other regions) (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ISM_LF; MRFI_CC430; __CC430F6137__
  group (top)
    ./: change_record.txt lnkCC430F6137.xcl main.c
  group bluerobin
    bluerobin/: BlueRobin_RX_433MHz.r43 BlueRobin_RX_868MHz.r43 BlueRobin_RX_915MHz.r43 BlueRobin_RX_API.h bm.h
  group driver
    driver/: adc12.c buzzer.c display.c display1.c ez430_chronos_datalogger_codesize_limited_drivers.r43 flash.c pmm.c ports.c radio.c rf1a.c timer.c vti_as.c vti_ps.c
  group include
    include/: project.h
  group logic
    logic/: acceleration.c altitude.c battery.c bluerobin.c clock.c datalog.c date.c menu.c rfbsl.c rfbsl.h rfsimpliciti.c temperature.c user.c
  group simpliciti
    simpliciti/: CC430_End_Device_433MHz.r43 CC430_End_Device_868MHz.r43 CC430_End_Device_915MHz.r43 simpliciti.h
  group simpliciti/Applications/application/End Device
    simpliciti/Applications/application/End Device/: main_ED_BM.c
  group simpliciti/Applications/configuration
    simpliciti/Applications/configuration/: smpl_nwk_config.dat
  group simpliciti/Applications/configuration/End Device
    simpliciti/Applications/configuration/End Device/: smpl_config.dat
  group simpliciti/Components/bsp
    simpliciti/Components/bsp/: bsp.c bsp.h bsp_macros.h
  group simpliciti/Components/bsp/boards/CC430EM
    simpliciti/Components/bsp/boards/CC430EM/: bsp_board.c bsp_board_defs.h bsp_button_defs.h bsp_config.h bsp_driver_defs.h bsp_drivers.c bsp_led_defs.h
  group simpliciti/Components/bsp/boards/CC430EM/bsp_external
    simpliciti/Components/bsp/boards/CC430EM/bsp_external/: mrfi_board_defs.h
  group simpliciti/Components/bsp/drivers
    simpliciti/Components/bsp/drivers/: bsp_buttons.h bsp_leds.h
  group simpliciti/Components/bsp/drivers/code
    simpliciti/Components/bsp/drivers/code/: bsp_buttons.c bsp_generic_buttons.h bsp_generic_leds.h bsp_leds.c
  group simpliciti/Components/bsp/mcus
    simpliciti/Components/bsp/mcus/: bsp_msp430_defs.h
  group simpliciti/Components/mrfi
    simpliciti/Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group simpliciti/Components/mrfi/radios/family5
    simpliciti/Components/mrfi/radios/family5/: mrfi_radio.c mrfi_radio_interface.c mrfi_radio_interface.h
  group simpliciti/Components/mrfi/smartrf/CC1101
    simpliciti/Components/mrfi/smartrf/CC1101/: smartrf_CC1101.h
  group simpliciti/Components/nwk
    simpliciti/Components/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group simpliciti/Components/nwk_applications
    simpliciti/Components/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
