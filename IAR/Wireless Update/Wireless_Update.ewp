# IAR project Wireless_Update.ewp, settings and files
configuration RAM Based Updater (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  General.GStackSize2: 256
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: RAM_BASED_RFBSL
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  A430.ADefines: RAM_BASED_RFBSL
  XLINK.XclFile: C:\Chronos RFBSL New\IAR_Chronos\ram_based_lnkcc430F6137.xcl
  XLINK.XlinkStackSize: 1
configuration 915MHz Flash Based Updater (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ISM_US
  XLINK.XclFile: flash_based_lnkcc430F6137.xcl
configuration 868MHz Flash Based Updater (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ISM_EU
  XLINK.XclFile: flash_based_lnkcc430F6137.xcl
configuration 433MHz Flash Based Updater (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ISM_LF
  XLINK.XclFile: flash_based_lnkcc430F6137.xcl
  group (top)
    ./: display.c display.h display1.c project_defs.h radio.c radio.h rf1a.c rf1a.h RFBSL_Low_Level_Init.s43 wbsl.c wbsl.h
